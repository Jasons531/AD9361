# Keil uVision project stm32l072_ad9361.uvprojx, settings and files
target stm32l072_ad9361 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CB STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: stm32l072_ad9361 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;..\AD9361;..\Console_commands;..\Platform_Generic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../Src/: gpio.c usart.c spi.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c FIFO_Uart.c delay.c
    ../AD9361/: ad9361.c ad9361_api.c ad9361_conv.c util.c
    ../Console_commands/: command.c console.c
    ../Platform_Generic/: platform.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim.c stm32l0xx_hal_gpio.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_spi.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_flash.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_flash_ex.c
  group Readme
    ../Readme/: readme.txt
software components: CMSIS:CORE 4.1.0
